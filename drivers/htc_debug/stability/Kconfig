## drivers/htc_debug/stability/Kconfig
```kconfig
config DIRTY_SYSTEM_DETECTOR
        default n
        bool "HTC dirty file detector for /system partition"
```
